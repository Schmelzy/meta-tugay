FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-mosquitto.conf-Enable-websockets.patch"
